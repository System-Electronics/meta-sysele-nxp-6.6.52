#
# Copyright (C)2024 KOAN sas - <https://koansoftware.com>
#

# change the NXP repo with the System Electronics custom one
ATF_SRC = "git://${TOPDIR}/../imx-atf-lf-6.6.52;branch=${SRCBRANCH}"
SRCBRANCH = "main"
SRCREV = "65f659e5f2e76338918da7369ef0ca262f51a200"
