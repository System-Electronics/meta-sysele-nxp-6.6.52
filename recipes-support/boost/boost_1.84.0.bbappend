#disable boost static library
BOOST_STATIC = "0"
